# Keil uVision project stc89c52.uvproj, settings and files
target stc89c52 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: stc89c52 +hex
  c flags: Optimize=9
  group startcode
    ./: STARTUP.A51 spin_userstart.c spin_userstart.h
  group usercode
    ./: spin_exinterupt.c spin_gpio.c spin_interupt.c spin_main.c spin_pwrmgr.c spin_timer.c spin_uart.c spin_watchdog.c one_os.c spin_cycle_queue.c spin_memory_manage.c xprintf.c
  group userinclu
    ./: spin_common.h spin_exinterupt.h spin_gpio.h spin_interupt.h spin_pwrmgr.h spin_timer.h spin_uart.h spin_watchdog.h one_os.h spin_cycle_queue.h spin_memory_manage.h xprintf.h
